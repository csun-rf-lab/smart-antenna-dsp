<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.13'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>ArrayTest2</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>bandwidth</value></param>
<param><key>value</key><value>100e6</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>center_frequency</value></param>
<param><key>value</key><value>1949.95e6</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>gain</value></param>
<param><key>value</key><value>60</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>1e6</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_0</value></param>
<param><key>file</key><value>/home/dave/Documents/USRP_DATA/ArrayTest2</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_0_0</value></param>
<param><key>file</key><value>/home/dave/Documents/USRP_DATA/ArrayTest1</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_0_1</value></param>
<param><key>file</key><value>/home/dave/Documents/USRP_DATA/ArrayTest0</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_0_2</value></param>
<param><key>file</key><value>/home/dave/Documents/USRP_DATA/ArrayTest3</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>qtgui_freq_sink_x</key>
<param><key>id</key><value>qtgui_freq_sink_x_0</value></param>
<param><key>bw</key><value>bandwidth</value></param>
<param><key>fc</key><value>center_frequency</value></param>
<param><key>fftsize</key><value>1024</value></param>
<param><key>label2</key><value></value></param>
<param><key>label3</key><value></value></param>
<param><key>label4</key><value></value></param>
<param><key>nconnections</key><value>4</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_1</value></param>
<param><key>autoscale</key><value>True</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value></value></param>
<param><key>width1</key><value>4</value></param>
<param><key>color2</key><value>"red"</value></param>
<param><key>label2</key><value></value></param>
<param><key>color3</key><value>"cyan"</value></param>
<param><key>label3</key><value></value></param>
<param><key>width3</key><value>4</value></param>
<param><key>color4</key><value>"black"</value></param>
<param><key>label4</key><value></value></param>
<param><key>color5</key><value>"green"</value></param>
<param><key>label5</key><value></value></param>
<param><key>width5</key><value>4</value></param>
<param><key>color6</key><value>"magenta"</value></param>
<param><key>label6</key><value></value></param>
<param><key>color7</key><value>"dark green"</value></param>
<param><key>label7</key><value></value></param>
<param><key>width7</key><value>4</value></param>
<param><key>color8</key><value>"dark red"</value></param>
<param><key>label8</key><value></value></param>
<param><key>name</key><value>"Uncorolated"</value></param>
<param><key>nconnections</key><value>4</value></param>
<param><key>size</key><value>1500</value></param>
<param><key>srate</key><value>samp_rate</value></param>
<param><key>tr_delay</key><value>0.000001</value></param>
<param><key>tr_level</key><value>0.001</value></param>
<param><key>tr_mode</key><value>qtgui.TRIG_MODE_NORM</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>update_time</key><value>0.5</value></param>
<param><key>ymax</key><value>0.1</value></param>
<param><key>ymin</key><value>-0.1</value></param>
</block>
<block>
<key>uhd_usrp_source</key>
<param><key>id</key><value>uhd_usrp_source_0</value></param>
<param><key>ant0</key><value>RX2</value></param>
<param><key>bw0</key><value>bandwidth</value></param>
<param><key>center_freq0</key><value>center_frequency</value></param>
<param><key>dc_offs_enb0</key><value>False</value></param>
<param><key>iq_imbal_enb0</key><value>False</value></param>
<param><key>norm_gain0</key><value>False</value></param>
<param><key>gain0</key><value>gain</value></param>
<param><key>ant1</key><value>RX2</value></param>
<param><key>bw1</key><value>bandwidth</value></param>
<param><key>center_freq1</key><value>center_frequency</value></param>
<param><key>dc_offs_enb1</key><value>False</value></param>
<param><key>iq_imbal_enb1</key><value>False</value></param>
<param><key>norm_gain1</key><value>False</value></param>
<param><key>gain1</key><value>gain</value></param>
<param><key>ant2</key><value>RX2</value></param>
<param><key>bw2</key><value>bandwidth</value></param>
<param><key>center_freq2</key><value>center_frequency</value></param>
<param><key>dc_offs_enb2</key><value>False</value></param>
<param><key>iq_imbal_enb2</key><value>False</value></param>
<param><key>norm_gain2</key><value>False</value></param>
<param><key>gain2</key><value>gain</value></param>
<param><key>ant3</key><value>RX2</value></param>
<param><key>bw3</key><value>bandwidth</value></param>
<param><key>center_freq3</key><value>center_frequency</value></param>
<param><key>dc_offs_enb3</key><value>False</value></param>
<param><key>iq_imbal_enb3</key><value>False</value></param>
<param><key>norm_gain3</key><value>False</value></param>
<param><key>gain3</key><value>gain</value></param>
<param><key>clock_rate</key><value>0.0</value></param>
<param><key>dev_addr</key><value>addr=192.168.10.2</value></param>
<param><key>dev_args</key><value>rx_lo_source=external,init_cals=BASIC|TX_ATTENUATION_DELAY|RX_GAIN_DELAY|PATH_DELAY|TX_LO_LEAKAGE_INTERNAL|LOOPBACK_RX_LO_DELAY</value></param>
<param><key>clock_source0</key><value>internal</value></param>
<param><key>sd_spec0</key><value>"A:0 A:1 B:0 B:1"</value></param>
<param><key>nchan</key><value>4</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>hide_cmd_port</key><value>False</value></param>
<param><key>hide_lo_controls</key><value>True</value></param>
<param><key>sync</key><value>sync</value></param>
</block>
<connection><source_block_id>uhd_usrp_source_0</source_block_id><sink_block_id>blocks_file_sink_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>uhd_usrp_source_0</source_block_id><sink_block_id>qtgui_freq_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>uhd_usrp_source_0</source_block_id><sink_block_id>qtgui_time_sink_x_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>uhd_usrp_source_0</source_block_id><sink_block_id>blocks_file_sink_0_0</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>uhd_usrp_source_0</source_block_id><sink_block_id>qtgui_freq_sink_x_0</sink_block_id><source_key>1</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>uhd_usrp_source_0</source_block_id><sink_block_id>qtgui_time_sink_x_1</sink_block_id><source_key>1</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>uhd_usrp_source_0</source_block_id><sink_block_id>blocks_file_sink_0</sink_block_id><source_key>2</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>uhd_usrp_source_0</source_block_id><sink_block_id>qtgui_freq_sink_x_0</sink_block_id><source_key>2</source_key><sink_key>2</sink_key></connection>
<connection><source_block_id>uhd_usrp_source_0</source_block_id><sink_block_id>qtgui_time_sink_x_1</sink_block_id><source_key>2</source_key><sink_key>2</sink_key></connection>
<connection><source_block_id>uhd_usrp_source_0</source_block_id><sink_block_id>blocks_file_sink_0_2</sink_block_id><source_key>3</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>uhd_usrp_source_0</source_block_id><sink_block_id>qtgui_freq_sink_x_0</sink_block_id><source_key>3</source_key><sink_key>3</sink_key></connection>
<connection><source_block_id>uhd_usrp_source_0</source_block_id><sink_block_id>qtgui_time_sink_x_1</sink_block_id><source_key>3</source_key><sink_key>3</sink_key></connection>
</flow_graph>
